# Keil uVision project CoreMark_Test_W5300_LWIP.uvprojx, settings and files
target CoreMark_Test_W5300_LWIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CorMark_Test_W5300 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../CoreMarkApp/App;../CoreMarkApp;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Utilities/3rdParty/MISC;../Libraries/ioLibrary_Driver;../Libraries/ioLibrary_Driver/Ethernet;../Libraries/ioLibrary_Driver/Ethernet/W5300;../Libraries/ioLibrary_Driver/Internet/DHCP;../Libraries/ioLibrary_Driver/Internet/DNS;../Libraries/lwip/src/include;../Port/ioLibrary_Driver/inc;../Port/lwip/inc
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: CoreMark_Task.c TCP_Task.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/CoreMarkApp/App
    ../CoreMarkApp/App/: app_coremarkapp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries/ioLibrary_Driver
    ../Libraries/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../Libraries/ioLibrary_Driver/Ethernet/W5300/: w5300.c
    ../Libraries/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../Libraries/ioLibrary_Driver/Internet/DNS/: dns.c
  group Port/ioLibrary_Driver
    ../Port/ioLibrary_Driver/src/: w5x00_bus.c w5x00_network.c
  group Libraries/lwip
    ../Libraries/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Libraries/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Libraries/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Libraries/lwip/src/netif/: ethernet.c
  group Port/lwip
    ../Port/lwip/src/: w5x00_lwip.c lwip_arch.c
  group Utilities
    ../Utilities/3rdParty/MISC/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c core_portme.c
software components: CMSIS:CORE 4.3.0
